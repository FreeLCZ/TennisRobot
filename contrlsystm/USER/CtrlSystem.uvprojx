# Keil uVision project CtrlSystem.uvprojx, settings and files
target CtrlSystem (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CtrlSystem +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\inc;..\USER;..\HARDWARE\PWM;..\HARDWARE\TOUCH;..\HARDWARE\ENCODER;..\HARDWARE\STEPCTRL;..\HARDWARE\TIMER;..\HARDWARE\PID;..\HARDWARE\STATE;..\HARDWARE\MATH;..\HARDWARE\USART;..\HARDWARE\USART6;..\HARDWARE\RECEIVER;..\HARDWARE\USRAT2;..\HARDWARE\TIM7;..\HARDWARE\MATHS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c main.c
  group HARDWARE
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/RECEIVER/: receiver.c
    ../HARDWARE/USRAT2/: usart2.c
    ../HARDWARE/TIM7/: tim7.c
    ../HARDWARE/MATHS/: maths.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_tim.c
